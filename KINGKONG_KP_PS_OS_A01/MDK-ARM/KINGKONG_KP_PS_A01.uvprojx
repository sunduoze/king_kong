# Keil uVision project KINGKONG_KP_PS_A01.uvprojx, settings and files
target KINGKONG_KP_PS_A01 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KINGKONG_KP_PS_A01 +hex
  AfterMake: D:\Program Files (x86)\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/STM32F103_512K_APP_new.bin ./KINGKONG_KP_PS_A01/KINGKONG_KP_PS_A01.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,HAL_V1_6_1,SWUST_FREESCALE_LIB_Enzo,BOOTLOADERx,DEBUG_MODE
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; .\app; .\bsp; .\lib; .\lib\RTT; .\lib\IAP; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; .\lib\stm_flash
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group App
    ./: ReadMe.txt
    ./app/: task_uart.c app_test_procedure.c app_debug.c
  group Bsp
    ./bsp/: bsp_delay.c bsp_uart.c bsp_io.c bsp_ad5683r.c bsp_mcp9805.c bsp_kingkong.cpp AD7124.c AD7124_regs.c bsp_iic1.c
  group Lib
    ./lib/: lib_crc16.c lib_cali.cpp
    ./lib/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ./lib/IAP/: common.c flash_if.c menu.c ymodem.c bootloader.c
    ./lib/stm_flash/: stm_flash.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Application/User
    ../Src/: main.c gpio.c can.c dac.c freertos.c iwdg.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.1.0
